# Keil uVision project Charge_Manager V1.0.00.uvprojx, settings and files
target project_template_release (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: HC32L130F8UA HDSC
  pack: HDSC.HC32L130.1.0.0
  cpu: IRAM(0x20000000,0x2000) IROM(0x00000000,0x10000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: project_template
  c flags: Optim=1 OneElfS=1 uC99=1
  c include: ..\..\..\..\mcu\common;..\source;..\..\..\..\driver\inc;.\my_sdk\my_gpio;.\my_sdk\my_systick;.\my_sdk\my_uart;.\my_sdk\my_pwm;.\function\manager;.\hardware\oled;.\hardware\mcp3426;.\my_sdk\my_i2c;.\function\gui
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x2000
  link misc: --keep=*Handler
  group common
    ./: startup_hc32l136.s
    ../../../../mcu/common/: system_hc32l136.c
  group source
    ../source/: main.c
  group my_sdk
    ./my_sdk/my_uart/: my_uart.c
    ./my_sdk/my_systick/: my_systick.c
    ./my_sdk/my_gpio/: my_gpio.c
    ./my_sdk/my_i2c/: my_i2c0.c my_i2c1.c
  group driver
    ../../../../driver/src/: ddl.c interrupts_hc32l136.c sysctrl.c uart.c gpio.c flash.c adt.c i2c.c
  group README
    ../: readme.txt
  group function
    ./function/manager/: manager.c manager.h
    ./function/gui/: gui.c gui.h
  group hardware
    ./hardware/oled/: oled.c oled.h font.h
    ./hardware/mcp3426/: mcp3426.c
software components: CMSIS:CORE 5.2.0
